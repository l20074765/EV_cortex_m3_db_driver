# Keil uVision project mVMC.uvproj, settings and files
target mVMC-V0.1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EV_BCD_DRV_V1.3_TST +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Firmware\InChip.sct
  link misc: --entry __main
  group APP
    ./APP/: main.c common.c task_device.c
  group API
    ./API/: logApi.c hopperAPi.c pcConApi.c billApi.c coinApi.c flashApi.c
  group DRIVERS
    ./Drivers/: uart0.c uart1.c uart2.c uart3.c buzzer.c I2C.c timer.c key.c pcoin.c MDB.c RS232.c EVB.c
  group FIRMWARE
    ./Firmware/: LPC1700PinCfg.c target.c vector_table.c zy_if.c
  group STARTUP
    ./Startup/: rt_sys_c.c rt_sys_s.s
  group uCOS-II
    ./uCOS_II/cpu/: Os_cpu_c.c
    ./uCOS_II/hook/: uCOS-II hook.lib
    ./uCOS_II/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_TIME.C OS_TASK.C OS_SEM.C OS_Q.C OS_MUTEX.C
